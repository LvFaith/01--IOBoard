# Keil uVision project SingleBoard.uvprojx, settings and files
target SingleBoard (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F413VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: SingleBoard +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F413xx
  c misc: --C99
  c include: ../Inc;           C:/Users/lvquanhui/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Drivers/STM32F4xx_HAL_Driver/Inc;           C:/Users/lvquanhui/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;           C:/Users/lvquanhui/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;           C:/Users/lvquanhui/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;           C:/Users/lvquanhui/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/include;           C:/Users/lvquanhui/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;           C:/Users/lvquanhui/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Drivers/CMSIS/Include;           ..\USER\CMSIS_OS_USER;           ..\USER\BSP;           ..\USER\Common;           ..\USER\DRV;           ..\USER\TRACE
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: freertos.c stm32f4xx_hal_msp.c gpio.c can.c main.c stm32f4xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/lvquanhui/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_can.c
  group Middlewares/FreeRTOS
    C:/Users/lvquanhui/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c tasks.c list.c queue.c timers.c croutine.c
    C:/Users/lvquanhui/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/Users/lvquanhui/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    C:/Users/lvquanhui/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group USER/BSP
    ../USER/BSP/: BspCan.c
  group USER/DRV
    ../USER/DRV/: DrvCanIO.c
  group USER/COMMON
    ../USER/Common/: CommonStream.c
  group USER/CMSIS_OS_USER
    ../USER/CMSIS_OS_USER/: CMSIS_OS_SUPPLEMENT.c
  group USER/TRACE
    ../USER/TRACE/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.1.0
